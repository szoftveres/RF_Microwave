options:
  parameters:
    generate_options: qt_gui
    id: fm_stereo
    output_language: python
    title: FM Radio
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: mono
  id: variable_qtgui_toggle_switch
  parameters:
    initPressed: 'False'
    label: Mono
    pressed: '1'
    released: '0'
    type: real
    value: '0'
  states: {}
- name: phasedelay
  id: variable_qtgui_range
  parameters:
    label: Stereo Phasing
    rangeType: int
    start: '0'
    step: '1'
    stop: '18'
    value: '9'
  states: {}
- name: rfgain
  id: variable_qtgui_dial_control
  parameters:
    label: RF Gain
    maximum: '35'
    minimum: '-20'
    showvalue: 'False'
    type: int
    value: '20'
  states: {}
- name: st_enh
  id: variable_qtgui_toggle_switch
  parameters:
    initPressed: 'False'
    label: Enhanced Stereo
    pressed: '0.25'
    released: '0'
    type: real
    value: '0'
  states: {}
- name: tuner_freq
  id: variable_qtgui_range
  parameters:
    label: Tuning
    rangeType: int
    start: '88000000'
    step: '100000'
    stop: '108000000'
    value: '95700000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1.0'
    type: float
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: audio_samp_rate*16
    tau: '75e-6'
  states: {}
- name: analog_fm_deemph_0_0
  id: analog_fm_deemph
  parameters:
    samp_rate: audio_samp_rate*16
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: default
    num_inputs: '2'
    samp_rate: audio_samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1000'
    high_cutoff_freq: '20000'
    low_cutoff_freq: '18000'
    samp_rate: audio_samp_rate*16
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_RECTANGULAR
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '100'
    high_cutoff_freq: '40000'
    low_cutoff_freq: '36000'
    samp_rate: audio_samp_rate*16
    type: fir_filter_fff
    width: '5000'
    win: window.WIN_RECTANGULAR
  states: {}
- name: band_pass_filter_0_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '2'
    high_cutoff_freq: '20000'
    low_cutoff_freq: '18000'
    samp_rate: audio_samp_rate*16
    type: fir_filter_fff
    width: '2000'
    win: window.WIN_RECTANGULAR
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: mono * 1000
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: mono * 1000
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: phasedelay
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: st_enh
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1 + (st_enh * 2)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1 + (st_enh * 2)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: 1 - (mono * 0.5)
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_1_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.1'
    init: '0'
    low: '-0.1'
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: '0.1'
    init: '0'
    low: '-0.1'
  states: {}
- name: blocks_threshold_ff_0_0_0
  id: blocks_threshold_ff
  parameters:
    high: '0.1'
    init: '0'
    low: '-0.1'
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '1.0'
    samp_rate: audio_samp_rate*16
    sensitivity: 19000*3.141592*2
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100000'
    decim: '2'
    gain: '1'
    samp_rate: audio_samp_rate*32
    type: fir_filter_ccf
    width: '300000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '16'
    gain: '1'
    samp_rate: audio_samp_rate*16
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '16'
    gain: '1'
    samp_rate: audio_samp_rate*16
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: audio_samp_rate*16
    fc: '0'
    fftsize: '512'
    freqhalf: 'False'
    label: Audio Baseband
    type: float
    ymin: '-100'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_samp_rate*32
    fc: '0'
    fftsize: '512'
    freqhalf: 'False'
    grid: 'True'
    label: RF Spectrum
    type: complex
    ymin: '-100'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: tuner_freq
    gain0: rfgain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: audio_samp_rate*32
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_vco_f_0, '0']
- [analog_fm_deemph_0, '0', blocks_float_to_complex_0, '0']
- [analog_fm_deemph_0, '0', low_pass_filter_0_0, '0']
- [analog_fm_deemph_0_0, '0', blocks_float_to_complex_0, '1']
- [analog_fm_deemph_0_0, '0', low_pass_filter_0_0_0, '0']
- [band_pass_filter_0, '0', blocks_threshold_ff_0_0_0, '0']
- [band_pass_filter_0_0, '0', blocks_add_const_vxx_0_0_0_0, '0']
- [band_pass_filter_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [band_pass_filter_0_1, '0', blocks_abs_xx_0, '0']
- [blocks_abs_xx_0, '0', blocks_delay_0, '0']
- [blocks_add_const_vxx_0_0_0, '0', blocks_threshold_ff_0, '0']
- [blocks_add_const_vxx_0_0_0_0, '0', blocks_threshold_ff_0_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_1, '1']
- [blocks_delay_0, '0', band_pass_filter_0_0, '0']
- [blocks_delay_0_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_sub_xx_1, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_sub_xx_1_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_const_vxx_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', band_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', audio_sink_0, '1']
- [blocks_multiply_const_vxx_2, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_multiply_xx_0_1, '0']
- [blocks_multiply_xx_0, '0', analog_fm_deemph_0, '0']
- [blocks_multiply_xx_0_1, '0', analog_fm_deemph_0_0, '0']
- [blocks_multiply_xx_1, '0', blocks_complex_to_arg_0, '0']
- [blocks_sub_xx_1, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_sub_xx_1_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_threshold_ff_0, '0', blocks_multiply_xx_0_1, '1']
- [blocks_threshold_ff_0_0, '0', blocks_multiply_xx_0, '1']
- [blocks_threshold_ff_0_0_0, '0', band_pass_filter_0_1, '0']
- [blocks_vco_f_0, '0', blocks_null_sink_0_0, '0']
- [low_pass_filter_0, '0', blocks_delay_0_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_xx_1, '0']
- [low_pass_filter_0_0, '0', blocks_add_xx_0, '1']
- [low_pass_filter_0_0, '0', blocks_sub_xx_1_0, '0']
- [low_pass_filter_0_0_0, '0', blocks_add_xx_0, '0']
- [low_pass_filter_0_0_0, '0', blocks_sub_xx_1, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
